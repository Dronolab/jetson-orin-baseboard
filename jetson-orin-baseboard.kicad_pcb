# Repository Dronolab/jetson-orin-baseboard (continued)

## KiCad design jetson-orin-baseboard.kicad_pcb (continued)

Schematic: usb.kicad_sch, USB Debug, DP

Parts:
C23, C25, C26, C33, C45, C59: C_10u_0402; 0402-cap; MPN CC0402MRX5R5BB106
C24, C27, C29, C30, C34, C35, C36, C37, C38, C39, C40, C50, C51, C52, C53, C54, C55, C56, C57, C60: C_100n_0402; 0402-cap; MPN GRM155R61H104KE14D
C28: C_10u_25V_0603; 0603-cap; MPN C1608X5R1E106M080AC
C31, C32, C41, C42, C43, C44, C46, C47, C48, C49: 100n; 0402-cap
C58: C_4u7_0402_25V; 0402-cap; MPN GRM155C61E475ME15J
C61: C_1u_0402_16V; 0402-cap; MPN C0402C105M4PACTU
D4: RB521S30T1G; SOD-523; MPN RB521S30T1G
D5, D6, D7, D8, D10: LTST-C190GKT; LED_0603; MPN LTST-C190GKT
D9: DF2S30FS; SOD-923; MPN DF2S30FS
J3: WE_632723300011_alt_symbol; WE_632723300011; MPN 632723300011
R11, R22, R23, R24, R25, R31, R32, R33, R34, R35, R36, R37, R55, R56: R_0R_0402; 0402-res; MPN ERJ2GE0R00X
R12, R14, R28, R38, R57: R_10k_0402; 0402-res; MPN CRCW040210K0FKEDHP
R13, R15, R29, R30: R_100k_0402; 0402-res; MPN CRCW0402100KFKEDHP
R16, R17, R19, R20, R61: R_4k7_0402; 0402-res; MPN MCS04020C4701FE000
R18, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54: R_1k_0402; 0402-res; MPN CR0402-FX-1001GLF
R21: 4x0R_0201_array; EXB18V; MPN EXB-18VR000X
R26, R27, R39, R40: R_200R_0402; 0402-res; MPN RC0402FR-07200RL
R58: R_2k2_0402; 0402-res; MPN RC0402FR-072K2L
R59, R60: R_2M0_0402; 0402-res; MPN AC0402FR-072ML
TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP17, TP18: TP_SMD_0_75MM; Testpoint_smd_0_75mm
TP16: TP; Testpoint_smd_0_75mm
U2: TPS65987; IC_TPS65987DDHRSHR; MPN TPS65987DDHRSHR
U3: W25Q80DVUXIE_TR; USON-8_2x3mm_P0.5mm; MPN W25Q80DVUXIE TR
U4: NCP730BMT330TBG; WSON6_TI_2x2mm; MPN NCP730BMT330TBG
U5: FT230XQ-R; WQFN-16-1EP_4x4mm; MPN FT230XQ-R
U6: TUSB1046-DCI; WQFN-40_1EP_6x3mm_Pitch0.4mm_EP4.7x2.7mm; MPN TUSB1046-DCIRNQT
U7, U9, U10, U11: TPD4E05U06QDQARQ1; USON-10_2.5x1.0mm_P0.5mm; MPN TPD4E05U06QDQARQ1
U8: AP22615; TSOT23-6; MPN AP22615AWU-7

Connections:
/USB Debug, DP/FTDI_3V3: C33.1, C50.1, C51.1, R28.1, R39.2, R40.2, U4.1 (OUT), U5.1 (VCCIO), U5.8 (3V3OUT), U5.10 (VCC)
/USB Debug, DP/FTDI_CBUS0: TP17.1, U5.12 (CBUS0)
/USB Debug, DP/FTDI_CBUS3: TP18.1, U5.14 (CBUS3); also elsewhere on the board
/USB Debug, DP/FTDI_LED_RX: D7.2, U5.11 (CBUS1)
/USB Debug, DP/FTDI_LED_TX: D8.2, U5.5 (CBUS2)
/USB Debug, DP/HPDIN: R31.2, U6.32 (HPDIN/RSVD2)
/USB Debug, DP/PDC_ADCIN1: R12.1, R13.2, U2.6 (ADCIN1)
/USB Debug, DP/PDC_ADCIN2: R14.1, R15.2, U2.10 (ADCIN2)
/USB Debug, DP/PDC_CTL1: R21.1, U2.18 (GPIO2)
/USB Debug, DP/PDC_FLIP: R21.3, U2.16 (GPIO0)
/USB Debug, DP/PDC_GPIO14: R26.1, U2.42 (GPIO14/PWM1)
/USB Debug, DP/PDC_GPIO15: R27.1, U2.43 (GPIO15/PWM2)
/USB Debug, DP/PDC_HPD2: R22.2, U2.31 (GPIO4)
/USB Debug, DP/PDC_I2C1_IRQn: R23.2, U2.29 (~I2C1_IRQ)
/USB Debug, DP/PDC_I2C1_SDA: R19.2, R25.2, U2.28 (I2C1_SDA)
/USB Debug, DP/PDC_I2C2_IRQn: TP9.1, U2.34 (~I2C2_IRQ)
/USB Debug, DP/PDC_I2C2_SCL: R17.2, TP10.1, U2.32 (I2C2_SCL)
/USB Debug, DP/PDC_I2C2_SDA: R16.2, TP11.1, U2.33 (I2C2_SDA)
/USB Debug, DP/PDC_I2C3_SCL: TP12.1, U2.21 (I2C3_SCL/GPIO5)
/USB Debug, DP/PDC_I2C3_SDA: TP13.1, U2.22 (I2C3_SDA/GPIO6)
/USB Debug, DP/PDC_LDO_1V8: C25.1, U2.35 (LDO_1V8)
/USB Debug, DP/PDC_RESET: R11.2, U2.44 (HRESET)
/USB Debug, DP/USBC0_5V_PEN: R55.1, R56.1, U2.49 (GPIO17/PP_EXT2)
/USB Debug, DP/USBC0_CC1: J3.A5 (CC1), U2.24 (C_CC1), U11.1 (IO1), U11.10 (IO1)
/USB Debug, DP/USBC0_CC2: J3.B5 (CC2), U2.26 (C_CC2), U11.5 (IO4), U11.6 (IO4)
/USB Debug, DP/USBC0_CONN_TX1_N: C54.2, J3.A3 (TX1-), U10.5 (IO4), U10.6 (IO4)
/USB Debug, DP/USBC0_CONN_TX1_P: C56.2, J3.A2 (TX1+), U10.4 (IO3), U10.7 (IO3)
/USB Debug, DP/USBC0_CONN_TX2_N: C55.2, J3.B3 (TX2-), U9.4 (IO3), U9.7 (IO3)
/USB Debug, DP/USBC0_CONN_TX2_P: C57.2, J3.B2 (TX2+), U9.5 (IO4), U9.6 (IO4)
/USB Debug, DP/USBC0_CTL0: R21.7, R37.1, U6.22 (CTL0/SDA)
/USB Debug, DP/USBC0_CTL1: R21.8, U6.23 (CTL1/HPDIN)
/USB Debug, DP/USBC0_DPEQ0: R47.1, R48.1, U6.14 (DPEQ0/A1)
/USB Debug, DP/USBC0_DPEQ1: R49.1, R50.1, U6.2 (DPEQ1)
/USB Debug, DP/USBC0_EQ0: R51.1, R52.1, U6.38 (EQ0)
/USB Debug, DP/USBC0_EQ1: R53.1, R54.1, U6.35 (EQ1)
/USB Debug, DP/USBC0_FLIP: R21.6, R36.1, U6.21 (FLIP/SCL)
/USB Debug, DP/USBC0_I2C_EN: R41.1, R42.1, U6.17 (I2C_EN)
/USB Debug, DP/USBC0_RX1_N: J3.B10 (RX1-), U6.31 (RX1_N), U10.2 (IO2), U10.9 (IO2)
/USB Debug, DP/USBC0_RX1_P: J3.B11 (RX1+), U6.30 (RX1_P), U10.1 (IO1), U10.10 (IO1)
/USB Debug, DP/USBC0_RX2_N: J3.A10 (RX2-), U6.39 (RX2_N), U9.1 (IO1), U9.10 (IO1)
/USB Debug, DP/USBC0_RX2_P: J3.A11 (RX2+), U6.40 (RX2_P), U9.2 (IO2), U9.9 (IO2)
/USB Debug, DP/USBC0_SBU_N: J3.A8 (SBU1), R59.2, U6.27 (SBU1), U7.2 (IO2), U7.9 (IO2)
/USB Debug, DP/USBC0_SBU_P: J3.B8 (SBU2), R60.2, U6.26 (SBU2), U7.1 (IO1), U7.10 (IO1)
/USB Debug, DP/USBC0_SSEQ0: R43.1, R44.1, U6.11 (SSEQ0/A0)
/USB Debug, DP/USBC0_SSEQ1: R45.1, R46.1, U6.3 (SSEQ1)
/USB Debug, DP/USBC0_TX1_N: C54.1, U6.34 (TX1_N)
/USB Debug, DP/USBC0_TX1_P: C56.1, U6.33 (TX1_P)
/USB Debug, DP/USBC0_TX2_N: C55.1, U6.36 (TX2_N)
/USB Debug, DP/USBC0_TX2_P: C57.1, U6.37 (TX2_P)
/USB Debug, DP/USBC0_VBUS: C60.1, C61.1, D9.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), R61.2, U2.3 (VBUS2), U2.13 (VBUS1), U8.1 (OUT)
/USB Debug, DP/USBC3_VBUS: C28.1, U4.4 (EN), U4.6 (IN)
/USB Debug, DP/USBSS0_RX_C_N: C38.2, U6.4 (SSRX_N)
/USB Debug, DP/USBSS0_RX_C_P: C36.2, U6.5 (SSRX_P)
/USB Debug, DP/USBSS0_TX_C_N: C39.2, U6.7 (SSTX_N)
/USB Debug, DP/USBSS0_TX_C_P: C37.2, U6.8 (SSTX_P)
/USB Debug, DP/~PDC_I2C3_IRQ: TP14.1, U2.23 (~I2C3_IRQ/GPIO7)
DEBUG_RXD: R32.1; also elsewhere on the board
DEBUG_TXD: R33.1; also elsewhere on the board
DP1_AUX_N: C32.1; also elsewhere on the board
DP1_AUX_P: C31.1; also elsewhere on the board
DP1_TXD0_N: C46.1; also elsewhere on the board
DP1_TXD0_P: C41.1; also elsewhere on the board
DP1_TXD1_N: C47.1; also elsewhere on the board
DP1_TXD1_P: C42.1; also elsewhere on the board
DP1_TXD2_N: C48.1; also elsewhere on the board
DP1_TXD2_P: C43.1; also elsewhere on the board
DP1_TXD3_P: C44.1; also elsewhere on the board
EEPROM_PWR: C27.1, D4.1, R18.1, U3.3 (~WP/IO2), U3.7 (~HOLD/IO3), U3.8 (VCC); also elsewhere on the board
GPIO10: R23.1; also elsewhere on the board
unnamed: D5.1, R26.2
unnamed: D6.1, R27.2
unnamed: D7.1, R39.1
unnamed: D8.1, R40.1
unnamed: D10.1, R61.1
unnamed: TP15.1, U2.30 (GPIO3/HPD)
unnamed: U2.7 (DRAIN2), U2.8 (DRAIN1), U2.15 (DRAIN1), U2.19 (DRAIN1), U2.52 (DRAIN2), U2.56 (DRAIN2), U2.57 (DRAIN2), U2.58 (DRAIN1)
unnamed: R33.2, U5.2 (RXD)
unnamed: R32.2, U5.15 (TXD)
unnamed: R35.2, U5.4 (~CTS)
unnamed: C35.1, R28.2, U5.9 (~RESET)
unnamed: R34.2, U5.16 (~RTS)
unnamed: C32.2, R29.1, U6.25 (AUX_N)
unnamed: C31.2, R30.1, U6.24 (AUX_P)
unnamed: TP16.1, U6.29 (CAD_SNK/RSVD1)
unnamed: C46.2, U6.10 (DP0_N)
unnamed: C41.2, U6.9 (DP0_P)
unnamed: C47.2, U6.13 (DP1_N)
unnamed: C42.2, U6.12 (DP1_P)
unnamed: C48.2, U6.16 (DP2_N)
unnamed: C43.2, U6.15 (DP2_P)
unnamed: C44.2, U6.18 (DP3_P)
unnamed: R56.2, R57.2, U8.4 (EN)
unnamed: R58.2, U8.5 (ISET)
PDC_MISO: R18.2, U2.36 (SPI_POCI), U3.2 (SO/IO1); also elsewhere on the board
PDC_MOSI: U2.37 (SPI_PICO), U3.5 (SI/IO0); also elsewhere on the board
PDC_SCLK: U2.38 (SPI_CLK), U3.6 (SCLK); also elsewhere on the board
PWR_SOFT: R34.1; also elsewhere on the board
SYS_SCL: R24.1, R36.2; also elsewhere on the board
SYS_SDA: R25.1, R37.2; also elsewhere on the board
USB0_D_N: J3.A7 (D-), J3.B7 (D-), U11.4 (IO3), U11.7 (IO3); also elsewhere on the board
USB0_D_P: J3.A6 (D+), J3.B6 (D+), U11.2 (IO2), U11.9 (IO2); also elsewhere on the board
USBC0_FLG: R38.1, U8.3 (FLG); also elsewhere on the board
USBC_HPD: R22.1, R31.1; also elsewhere on the board
USBPD_HV: C53.1, C58.1, U2.11 (PP_HV1); also elsewhere on the board
USBSS0_RX_N: C36.1; also elsewhere on the board
USBSS0_RX_P: C38.1; also elsewhere on the board
USBSS0_TX_N: C37.1; also elsewhere on the board
USBSS0_TX_P: C39.1; also elsewhere on the board
USB_FTDI_N: U5.7 (USBDM); also elsewhere on the board
USB_FTDI_P: U5.6 (USBDP); also elsewhere on the board
~PDC_CS: U2.39 (~SPI_CS), U3.1 (~CS); also elsewhere on the board

Notes on the sheet:
USB-UART Bridge
POWER DOWN
USB PD Controller
USB-PD Source/Sink
USB-C 0 Display Port alt mode
4 LANE DP
CONFIGURATION
USBC0
USB + 2 LANE DP
CTL0
CTL1
USB ONLY

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
Board: 8 copper layers, 443 parts (160 on the bottom side), 373 nets, no tracks yet.

Other parts of the board:
C123: C_10u_0402; 0402-cap
C124: C_100n_0402; 0402-cap
D57: LTST-C190GKT; LED_0603
D58, D59: TPD1E0B04DPYR; XDFN-2_1x0.60mm
J1: 533980471; Molex_PicoBlade_53398-0471_1x04-1MP_P1.25mm_Vertical
R85, R86: R_27R_0402; 0402-res
R161: R_200R_0402; 0402-res
R163: 4x1000R_0402_array; R_Array_4x0402
SP8: 9774025151
e: TP_SMD_0_75MM; Testpoint_smd_0_75mm

Their connections:
/Cameras/CAM1_I2C_SDA: R163.8; also elsewhere on the board
/USB Debug, DP/FTDI_CBUS3: e.1; also elsewhere on the board
USB2_D_N: D58.1; also elsewhere on the board
USB2_D_P: D59.1; also elsewhere on the board
USB_FTDI_N: R85.1; also elsewhere on the board
USB_FTDI_P: R86.1; also elsewhere on the board

Notices in the files:
parts and their libraries:
License: Apache-2.0
License: MIT
